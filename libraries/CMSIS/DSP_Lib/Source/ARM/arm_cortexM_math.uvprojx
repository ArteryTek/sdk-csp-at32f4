# Keil uVision project arm_cortexM_math.uvprojx, settings and files
target M0l (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm_cortexM0l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\..\Include;..\..\..\CM4\CoreSupport
  asm define: ARM_MATH_CM0
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group BasicMathFunctions
    ../BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
  group FastMathFunctions
    ../FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group ComplexMathFunctions
    ../ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group FilteringFunctions
    ../FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_partial_f32.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_q7.c arm_conv_q15.c arm_conv_q31.c arm_correlate_f32.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q7.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q7.c arm_fir_q15.c arm_fir_q31.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q7.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c arm_correlate_opt_q15.c arm_conv_opt_q7.c arm_conv_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_opt_q15.c arm_correlate_opt_q7.c arm_correlate_fast_opt_q15.c arm_conv_fast_opt_q15.c arm_conv_partial_fast_opt_q15.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c
  group MatrixFunctions
    ../MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_inverse_f64.c
  group TransformFunctions
    ../TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c arm_bitreversal.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_f32.c arm_cfft_radix8_f32.c arm_bitreversal2.S arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_cfft_q31.c arm_cfft_q15.c
  group ControllerFunctions
    ../ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group StatisticsFunctions
    ../StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group SupportFunctions
    ../SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
  group CommonTables
    ../CommonTables/: arm_common_tables.c arm_const_structs.c
target M0b (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM0b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM0, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM0
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M3l (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM3l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM3, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM3
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M3b (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: arm_cortexM3b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM3, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM3
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M4l (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\..\Include;..\..\..\CM4\CoreSupport
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M4b (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: arm_cortexM4b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M4lf (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4lf_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT = 1
  c misc: --fpmode=ieee_full
  c include: ..\..\..\Include;..\..\..\CM4\CoreSupport
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M4bf (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: arm_cortexM4bf_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT = 1, ARM_MATH_BIG_ENDIAN
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M7l (ARM-ADS)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M7b (ARM-ADS)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: arm_cortexM7b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M7lfsp (ARM-ADS)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfsp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT = 1
  c misc: --fpmode=ieee_full
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M7bfsp (ARM-ADS)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: arm_cortexM7bfsp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT = 1, ARM_MATH_BIG_ENDIAN
  c misc: --fpmode=ieee_full
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M7lfdp (ARM-ADS)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfdp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: as above
  c misc: --fpmode=ieee_full
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target M7bfdp (ARM-ADS)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: arm_cortexM7bfdp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: as above
  c misc: --fpmode=ieee_full
  c include: ..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
